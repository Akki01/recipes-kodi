SRCREV = "46902dfedfd210fadb0a9db7a903f14754e6a8c3"
RDEPENDS_${PN} += "alsa-plugins"
